# Keil uVision project STM32G0B1CBT6.uvprojx, settings and files
target STM32G0B1CBT6 (6160000::V6.16::ARMCLANG)
  device: STM32G0B1CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32G0B1CBT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Common;..\Include\Flash;../Include/Timers;../Include/SerialPort;../Include/FDCAN;../Include/TMC2209;../Include/MT6701;../Include/PIDControl;../Include/StepMotor;../Libraries/FreeModbus/port;../Libraries/FreeModbus/modbus;../Libraries/FreeModbus/modbus/include;../Libraries/FreeModbus/modbus/rtu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: m_task.c main.c gpio.c crc.c dma.c fdcan.c i2c.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Common/
    ../Common/: Common.c
  group Include/Flash
    ../Include/Flash/: m_flash.c
  group Include/Timers
    ../Include/Timers/: m_timers.c
  group Include/SerialPort
    ../Include/SerialPort/: serialport.c
  group Include/FDCAN
    ../Include/FDCAN/: m_fdcan.c
  group Include/MT6701
    ../Include/MT6701/: MT6701.c
  group Include/TMC2209
    ../Include/TMC2209/: TMC2209.c
  group Include/PIDControl
    ../Include/PIDControl/: PIDControl.c
  group Include/StepMotor
    ../Include/StepMotor/: Stepper_control.c
  group Libraries/FreeModbus
    ../Libraries/FreeModbus/port/: portevent.c portserial.c
    ../Libraries/FreeModbus/: port.c
    ../Libraries/FreeModbus/modbus/: mb.c
    ../Libraries/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../Libraries/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Libraries/FreeModbus/modbus/include/: mbfunuserf.c
software components: CMSIS:CORE 5.5.0
